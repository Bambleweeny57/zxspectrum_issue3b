File: src/issue3b.kicad_pcb (KiCad board)
At the start: 2 copper layers, 213.1 x 129 mm, 0 parts

Commit message: created gerbers
Routing:
- net (no net): track 24874.4 -> 24813.4 mm
